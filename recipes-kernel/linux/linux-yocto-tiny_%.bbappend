KERNEL_FEATURES_append = " features/overlayfs/overlayfs.scc"
