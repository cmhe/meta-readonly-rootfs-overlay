require readonly-rootfs-overlay-init-script.inc
